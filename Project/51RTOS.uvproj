# Keil uVision project 51RTOS.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 51RTOS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\51OS;..\APP;..\BSP;..\HARDWARE;..\..\51-OS;..\Project
  asm include: ..\51OS;..\HARDWARE
  group HARDWARE
    ../HARDWARE/: led.c
  group APP
    ../APP/: app.c app.h
  group BSP
    ../BSP/: bsp.c
  group 51OS
    ./: STARTUP.A51
    ../51OS/: OS.c OS.h TASKSW.c
